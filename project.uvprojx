# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartHome +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=68 --diag_suppress=111 --diag_suppress=550 --locale=english
  c include: .\User;.\System;.\Start;.\Library;.\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    User/: main.c stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
  group Start
    Start/: startup_stm32f10x_hd.s core_cm3.c system_stm32f10x.c core_cm3.h stm32f10x.h system_stm32f10x.h
  group Hardware
    Hardware/: ADC.c Beep.c bsp_lcd.c DHT.c Key.c LED.c Relay.c RGB.c Serial.c Ui.c Voice.c WiFi.c ADC.h Beep.h beep_1.h bsp_font.h bsp_lcd.h DHT.h hum_1.h hz.h illu_1.h Key.h LED.h led_1.h mq2_1.h Relay.h relay_1.h RGB.h rgb_1.h Serial.h tem_1.h Ui.h Voice.h WiFi.h
  group Library
    Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    System/: Delay.c Delay.h
software components: CMSIS:CORE 5.2.0
